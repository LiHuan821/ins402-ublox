<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\rtk_ins_m7_0\rtk_ins.ewp</path>
    </project>
    <batchBuild />
</workspace>
