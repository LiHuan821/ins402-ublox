# IAR project rtk_ins_bak.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT4BB_M7 Cypress CYT4BB_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: tviibh4m; CYT4BB8CEE; CY_USE_PSVP=0; CY_MCU_rev_a; CPU_BOARD_REVA; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\app; ..\..\app\include; ..\..\app\user; ..\..\gnss; ..\..\gnss\include; ..\..\gnss\src; ..\..\ins; ..\..\ins\include; ..\..\ins\src; ..\..\linker; ..\..\platform; ..\..\platform\Buffer; ..\..\platform\Buffer\include; ..\..\platform\Buffer\src; ..\..\platform\Common; ..\..\platform\Common\include; ..\..\platform\Common\src; ..\..\platform\cypress_sdk; ..\..\platform\cypress_sdk\flash; ..\..\platform\cypress_sdk\power; ..\..\platform\cypress_sdk\sw_timer; ..\..\platform\CYT4BB; ..\..\platform\CYT4BB\board; ..\..\platform\CYT4BB\board\ip; ..\..\platform\CYT4BB\board\mcureg; ..\..\platform\CYT4BB\cmsis; ..\..\platform\CYT4BB\cmsis\include; ..\..\platform\CYT4BB\hal; ..\..\platform\CYT4BB\hal\adc; ..\..\platform\CYT4BB\hal\audioss; ..\..\platform\CYT4BB\hal\canfd; ..\..\platform\CYT4BB\hal\cpu; ..\..\platform\CYT4BB\hal\crypto; ..\..\platform\CYT4BB\hal\crypto\libs; ..\..\platform\CYT4BB\hal\dma; ..\..\platform\CYT4BB\hal\ethernet; ..\..\platform\CYT4BB\hal\evtgen; ..\..\platform\CYT4BB\hal\flash; ..\..\platform\CYT4BB\hal\gpio; ..\..\platform\CYT4BB\hal\ipc; ..\..\platform\CYT4BB\hal\lin; ..\..\platform\CYT4BB\hal\lvd; ..\..\platform\CYT4BB\hal\mcwdt; ..\..\platform\CYT4BB\hal\mpu; ..\..\platform\CYT4BB\hal\prot; ..\..\platform\CYT4BB\hal\scb; ..\..\platform\CYT4BB\hal\sd_host; ..\..\platform\CYT4BB\hal\smartio; ..\..\platform\CYT4BB\hal\smif; ..\..\platform\CYT4BB\hal\srom; ..\..\platform\CYT4BB\hal\sysclk; ..\..\platform\CYT4BB\hal\sysflt; ..\..\platform\CYT4BB\hal\sysint; ..\..\platform\CYT4BB\hal\syslib; ..\..\platform\CYT4BB\hal\syslib\iar; ..\..\platform\CYT4BB\hal\syspm; ..\..\platform\CYT4BB\hal\sysreghc; ..\..\platform\CYT4BB\hal\sysreset; ..\..\platform\CYT4BB\hal\sysrtc; ..\..\platform\CYT4BB\hal\systick; ..\..\platform\CYT4BB\hal\syswdt; ..\..\platform\CYT4BB\hal\tcpwm; ..\..\platform\CYT4BB\hal\trigmux; ..\..\platform\CYT4BB\interrupts; ..\..\platform\CYT4BB\startup; ..\..\platform\CYT4BB\startup\include; ..\..\platform\CYT4BB\startup\src; ..\..\platform\CYT4BB\system; ..\..\platform\CYT4BB\system\include; ..\..\platform\CYT4BB\system\src; ..\..\platform\driver; ..\..\platform\driver\include; ..\..\platform\driver\src; ..\..\platform\filter; ..\..\platform\filter\include; ..\..\platform\filter\src; ..\..\platform\sensors; ..\..\platform\tool; ..\..\platform\tool\include; ..\..\platform\tool\src; ..\..\platform\UARTComm; ..\..\platform\utility; ..\..\platform\utility\include; ..\..\platform\utility\src
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtk_ins.srec
  ILINK.IlinkOutputFile: rtk_ins.hex
  ILINK.IlinkConfigDefines: _CORE_$PROJ_FNAME$_=0; _LINK_$LINK_LOCATION$_=0
  ILINK.IlinkIcfFile: ..\..\linker\linker_directives_tviibh.icf
  ILINK.IlinkAdditionalLibs: ..\..\platform\CYT4BB\hal\crypto\libs\libcrypto_client_cm7_0_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../app/: appVersion.h main_cm7_0.c taskDataAcquisition.c taskDataAcquisition.h taskGnssDataAcq.c taskRTK.c
  group app/include
    ../../app/include/: app_version.h cy_project.h
  group app/user
    ../../app/user/: dataProcessingAndPresentation.c user_message.c user_message.h UserAlgorithm.c UserAlgorithm.h userAPI.h
  group gnss/include
    ../../gnss/include/: ats_gnss_math.h ephemeris.h gnss_datatype.h gnss_filter.h gnssapp.h gpsAPI.h gpsconfig.h lambda.h model.h nmea_support.h print_nema.h pvt_eng.h RingBuffer.h rtcm.h rtk_eng.h rtkcmn.h rtklib_core.h taskGnssDataAcq.h taskRTK.h typedefs.h
  group gnss/src
    ../../gnss/src/: ats_gnss_math.c ephemeris.c gnss_filter.c lambda.c model.c print_nema.c pvt_eng.c RingBuffer.c rtcm.c rtk_eng.c rtkcmn.c
  group ins
    ../../ins/: CMakeLists.txt ins_interface_API.h
  group ins/include
    ../../ins/include/: cmatrix.h datatype.h define.h earth.h ginsdebug.h insmech.h insoutmsg.h lcgnssupdate.h lcinsupdate.h lcstruct.h lcsystem.h loosecoupleset.h matrix_wu.h orientation.h zuptdetect.h
  group ins/src
    ../../ins/src/: cmatrix.c earth.c ginsdebug.c gnss_ins_interface.c ins_interface.c insmech.c insoutmsg.c lcgnssupdate.c lcinsupdate.c lcsystem.c loosecoupleset.c matrix_wu.c orientation.c P1Packet.c zuptdetect.c
  group linker
    ../../linker/: linker_directives_tviibh.icf
  group platform
    ../../platform/: commAPI.h configurationAPI.h gnss_data_api.h hwAPI.h platform_version.h platformAPI.h
  group platform/Buffer/include
    ../../platform/Buffer/include/: buffer.h
  group platform/Buffer/src
    ../../platform/Buffer/src/: buffer.c
  group platform/Common/include
    ../../platform/Common/include/: GlobalConstants.h scaling.h ucb_packet_struct.h utilities.h
  group platform/Common/src
    ../../platform/Common/src/: utilities.c
  group platform/cypress_sdk/flash
    ../../platform/cypress_sdk/flash/: cy_mw_flash.c cy_mw_flash.h
  group platform/cypress_sdk/power
    ../../platform/cypress_sdk/power/: cy_power.c cy_power.h
  group platform/cypress_sdk/sw_timer
    ../../platform/cypress_sdk/sw_timer/: cy_sw_tmr.c cy_sw_tmr.h
  group platform/CYT4BB/board
    ../../platform/CYT4BB/board/: bb_bsp_tviibh4m.h bb_bsp_tviibh4m_reva.h bb_bsp_tviibh4m_reva_bak.h.bak bb_bsp_tviibh4m_revb.h cy_device_headers.h cyt4bb5cee.h cyt4bb5ces.h cyt4bb7cee.h cyt4bb7ces.h cyt4bb8cee.h cyt4bb8ces.h cyt4bb_config.h cyt4bbbcee.h cyt4bbbces.h gpio_cyt4bb_100_teqfp.h gpio_cyt4bb_144_teqfp.h gpio_cyt4bb_176_teqfp.h gpio_cyt4bb_272_bga.h
  group platform/CYT4BB/board/ip
    ../../platform/CYT4BB/board/ip/: cyip_backup_v3.h cyip_canfd.h cyip_cpuss.h cyip_crypto.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth_v2.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_gpio_v3.h cyip_headers.h cyip_hsiom_v3.h cyip_i2s_v2.h cyip_ipc.h cyip_lin.h cyip_pass.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_scb_v2.h cyip_sdhc.h cyip_sflash_v2.h cyip_smartio_v3.h cyip_smif_v2.h cyip_srss_v3.h cyip_tcpwm_v2.h
  group platform/CYT4BB/board/mcureg
    ../../platform/CYT4BB/board/mcureg/: cyreg_backup.h cyreg_canfd.h cyreg_cpuss.h cyreg_crypto.h cyreg_dmac.h cyreg_dw.h cyreg_efuse.h cyreg_efuse_data.h cyreg_eth.h cyreg_evtgen.h cyreg_fault.h cyreg_flashc.h cyreg_gpio.h cyreg_hsiom.h cyreg_i2s.h cyreg_ipc.h cyreg_lin.h cyreg_pass.h cyreg_peri.h cyreg_peri_ms.h cyreg_peri_pclk.h cyreg_prot.h cyreg_scb.h cyreg_sdhc.h cyreg_sflash.h cyreg_smartio.h cyreg_smif.h cyreg_srss.h cyreg_tcpwm.h mcureg.h
  group platform/CYT4BB/cmsis/include
    ../../platform/CYT4BB/cmsis/include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_ghs.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h core_cm4.h core_cm7.h mpu_armv7.h
  group platform/CYT4BB/hal/adc
    ../../platform/CYT4BB/hal/adc/: cy_adc.c cy_adc.h
  group platform/CYT4BB/hal/audioss
    ../../platform/CYT4BB/hal/audioss/: cy_i2s.c cy_i2s.h
  group platform/CYT4BB/hal/canfd
    ../../platform/CYT4BB/hal/canfd/: cy_canfd.c cy_canfd.h cy_canfd_config.h
  group platform/CYT4BB/hal/cpu
    ../../platform/CYT4BB/hal/cpu/: cy_cpu.c cy_cpu.h
  group platform/CYT4BB/hal/crypto
    ../../platform/CYT4BB/hal/crypto/: cy_crypto.h cy_crypto_common.h cy_crypto_config.c cy_crypto_config.h cy_crypto_server.h
  group platform/CYT4BB/hal/crypto/libs
    ../../platform/CYT4BB/hal/crypto/libs/: libcrypto_client_cm7_0_iar.a libcrypto_client_cm7_1_iar.a libcrypto_client_cm7_ghs.a libcrypto_server_cm0plus_ghs.a libcrypto_server_cm0plus_iar.a
  group platform/CYT4BB/hal/dma
    ../../platform/CYT4BB/hal/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group platform/CYT4BB/hal/ethernet
    ../../platform/CYT4BB/hal/ethernet/: cdn_errno.h cdn_stdint.h cedi.h cps_v2.h cy_ethif.c cy_ethif.h cy_ethif_defines.h edd.c edd_int.h edd_rx.c edd_tx.c emac_regs.h emac_regs_macro.h log.h
  group platform/CYT4BB/hal/evtgen
    ../../platform/CYT4BB/hal/evtgen/: cy_evtgen.c cy_evtgen.h
  group platform/CYT4BB/hal/flash
    ../../platform/CYT4BB/hal/flash/: cy_flash.c cy_flash.h
  group platform/CYT4BB/hal/gpio
    ../../platform/CYT4BB/hal/gpio/: cy_gpio.c cy_gpio.h
  group platform/CYT4BB/hal/ipc
    ../../platform/CYT4BB/hal/ipc/: cy_ipc_config.h cy_ipc_drv.c cy_ipc_drv.h cy_ipc_pipe.c cy_ipc_pipe.h cy_ipc_sema.c cy_ipc_sema.h
  group platform/CYT4BB/hal/lin
    ../../platform/CYT4BB/hal/lin/: cy_lin.c cy_lin.h
  group platform/CYT4BB/hal/lvd
    ../../platform/CYT4BB/hal/lvd/: cy_lvd.c cy_lvd.h
  group platform/CYT4BB/hal/mcwdt
    ../../platform/CYT4BB/hal/mcwdt/: cy_mcwdt.c cy_mcwdt.h
  group platform/CYT4BB/hal/mpu
    ../../platform/CYT4BB/hal/mpu/: cy_mpu.c cy_mpu.h
  group platform/CYT4BB/hal/prot
    ../../platform/CYT4BB/hal/prot/: cy_prot.c cy_prot.h
  group platform/CYT4BB/hal/scb
    ../../platform/CYT4BB/hal/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group platform/CYT4BB/hal/sd_host
    ../../platform/CYT4BB/hal/sd_host/: cy_sd_host.c cy_sd_host.h
  group platform/CYT4BB/hal/smartio
    ../../platform/CYT4BB/hal/smartio/: cy_smartio.c cy_smartio.h
  group platform/CYT4BB/hal/smif
    ../../platform/CYT4BB/hal/smif/: cy_smif.c cy_smif.h cy_smif_memslot.c cy_smif_memslot.h
  group platform/CYT4BB/hal/srom
    ../../platform/CYT4BB/hal/srom/: cy_srom.c cy_srom.h
  group platform/CYT4BB/hal/sysclk
    ../../platform/CYT4BB/hal/sysclk/: cy_sysclk.c cy_sysclk.h
  group platform/CYT4BB/hal/sysflt
    ../../platform/CYT4BB/hal/sysflt/: cy_sysflt.c cy_sysflt.h cy_sysflt_config.h
  group platform/CYT4BB/hal/sysint
    ../../platform/CYT4BB/hal/sysint/: cy_sysint.c cy_sysint.h
  group platform/CYT4BB/hal/syslib
    ../../platform/CYT4BB/hal/syslib/: cy_syslib.c cy_syslib.h
  group platform/CYT4BB/hal/syslib/iar
    ../../platform/CYT4BB/hal/syslib/iar/: cy_syslib_iar.s
  group platform/CYT4BB/hal/syspm
    ../../platform/CYT4BB/hal/syspm/: cy_syspm.c cy_syspm.h
  group platform/CYT4BB/hal/sysreghc
    ../../platform/CYT4BB/hal/sysreghc/: cy_sysreghc.c cy_sysreghc.h
  group platform/CYT4BB/hal/sysreset
    ../../platform/CYT4BB/hal/sysreset/: cy_sysreset.c cy_sysreset.h
  group platform/CYT4BB/hal/sysrtc
    ../../platform/CYT4BB/hal/sysrtc/: cy_sysrtc.c cy_sysrtc.h
  group platform/CYT4BB/hal/systick
    ../../platform/CYT4BB/hal/systick/: cy_systick.c cy_systick.h
  group platform/CYT4BB/hal/syswdt
    ../../platform/CYT4BB/hal/syswdt/: cy_syswdt.c cy_syswdt.h
  group platform/CYT4BB/hal/tcpwm
    ../../platform/CYT4BB/hal/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group platform/CYT4BB/hal/trigmux
    ../../platform/CYT4BB/hal/trigmux/: cy_trigmux.c cy_trigmux.h
  group platform/CYT4BB/interrupts
    ../../platform/CYT4BB/interrupts/: cy_interrupt_map.c cy_interrupt_map_cm0plus.h cy_interrupt_map_cm7_0.h cy_interrupt_map_cm7_1.h
  group platform/CYT4BB/startup/include
    ../../platform/CYT4BB/startup/include/: startup_customize.h
  group platform/CYT4BB/startup/src
    ../../platform/CYT4BB/startup/src/: startup.c startup_cm7.s
  group platform/CYT4BB/system/include
    ../../platform/CYT4BB/system/include/: system_cyt4bb.h
  group platform/CYT4BB/system/src
    ../../platform/CYT4BB/system/src/: system_tviibh4m_cm7.c
  group platform/driver/include
    ../../platform/driver/include/: led.h time_ref.h uart.h uart2_isr.h uart5_isr.h uart7_isr.h uart9_isr.h usb_uart.h usb_uart_isr.h
  group platform/driver/src
    ../../platform/driver/src/: led.c time_ref.c uart.c uart2_isr.c uart5_isr.c uart7_isr.c uart9_isr.c usb_uart.c usb_uart_isr.c
  group platform/filter/include
    ../../platform/filter/include/: filter.h lowpass_filter.h
  group platform/filter/src
    ../../platform/filter/src/: filter.c lowpass_filter.c
  group platform/sensors
    ../../platform/sensors/: calibrationAPI.h eepromAPI.h sensorsAPI.h
  group platform/tool/include
    ../../platform/tool/include/: BitStatus.h configuration.h crc.h crc16.h debug.h Indices.h parameters.h serial_port.h ucb_packet.h xbowsp_algorithm.h
  group platform/tool/src
    ../../platform/tool/src/: configuration.c crc.c crc16.c debug.c parameters.c platform.c send_packet.c serial_port.c ucb_packet.c
  group platform/UARTComm
    ../../platform/UARTComm/: CommonMessages.c CommonMessages.h
  group platform/utility/include
    ../../platform/utility/include/: _timeval.h constants.h nav_math.h scaling.h utils.h
  group platform/utility/src
    ../../platform/utility/src/: nav_math.c utils.c
