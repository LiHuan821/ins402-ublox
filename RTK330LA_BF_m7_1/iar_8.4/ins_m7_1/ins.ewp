# IAR project ins.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT4BF_M7 Cypress CYT4BF_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: tviibh8m; char_t=char; float32_t=float; float64_t=double; CYT4BFBCHS; CY_USE_PSVP=0; CY_MCU_rev_b; CPU_BOARD_REVA; CY_CORE_CM7_1; BT_ENABLE=0; CANFD_ENABLE=0; GT_PACKET=1; RTCM_CHANNEL=0; STARTUP_GET_LOCATION=1; VERSION_INS_APP=$APP_VERSION$; TIME_INS_APP=$COMPILE_TIME$; AUTHOR_INS_APP=$COMPILE_AUTHOR$; COMMIT_INS_APP=$GIT_COMMIT$; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\mem_share; ..\..\app; ..\..\app\include; ..\..\app\user; ..\..\ins; ..\..\ins\include; ..\..\linker; ..\..\platform; ..\..\platform\cypress_sdk; ..\..\platform\cypress_sdk\flash; ..\..\platform\cypress_sdk\power; ..\..\platform\cypress_sdk\sw_timer; ..\..\platform\CYT4BF; ..\..\platform\CYT4BF\board; ..\..\platform\CYT4BF\board\ip; ..\..\platform\CYT4BF\board\mcureg; ..\..\platform\CYT4BF\cmsis; ..\..\platform\CYT4BF\cmsis\include; ..\..\platform\CYT4BF\hal_common; ..\..\platform\CYT4BF\hal_common\adc; ..\..\platform\CYT4BF\hal_common\canfd; ..\..\platform\CYT4BF\hal_common\crypto; ..\..\platform\CYT4BF\hal_common\dma; ..\..\platform\CYT4BF\hal_common\evtgen; ..\..\platform\CYT4BF\hal_common\flash; ..\..\platform\CYT4BF\hal_common\gpio; ..\..\platform\CYT4BF\hal_common\ipc; ..\..\platform\CYT4BF\hal_common\lin; ..\..\platform\CYT4BF\hal_common\lvd; ..\..\platform\CYT4BF\hal_common\mcwdt; ..\..\platform\CYT4BF\hal_common\mpu; ..\..\platform\CYT4BF\hal_common\prot; ..\..\platform\CYT4BF\hal_common\scb; ..\..\platform\CYT4BF\hal_common\smartio; ..\..\platform\CYT4BF\hal_common\srom; ..\..\platform\CYT4BF\hal_common\sysflt; ..\..\platform\CYT4BF\hal_common\sysint; ..\..\platform\CYT4BF\hal_common\syslib; ..\..\platform\CYT4BF\hal_common\syslib\ghs; ..\..\platform\CYT4BF\hal_common\syslib\iar; ..\..\platform\CYT4BF\hal_common\syspm; ..\..\platform\CYT4BF\hal_common\sysreset; ..\..\platform\CYT4BF\hal_common\sysrtc; ..\..\platform\CYT4BF\hal_common\systick; ..\..\platform\CYT4BF\hal_common\syswdt; ..\..\platform\CYT4BF\hal_common\tcpwm; ..\..\platform\CYT4BF\hal_common\trigmux; ..\..\platform\CYT4BF\hal_drivers; ..\..\platform\CYT4BF\hal_drivers\audioss; ..\..\platform\CYT4BF\hal_drivers\canfd; ..\..\platform\CYT4BF\hal_drivers\cpu; ..\..\platform\CYT4BF\hal_drivers\crypto; ..\..\platform\CYT4BF\hal_drivers\crypto\libs; ..\..\platform\CYT4BF\hal_drivers\ethernet; ..\..\platform\CYT4BF\hal_drivers\flexray; ..\..\platform\CYT4BF\hal_drivers\flexray\api; ..\..\platform\CYT4BF\hal_drivers\flexray\ccal; ..\..\platform\CYT4BF\hal_drivers\flexray\fhal; ..\..\platform\CYT4BF\hal_drivers\sd_host; ..\..\platform\CYT4BF\hal_drivers\smif; ..\..\platform\CYT4BF\hal_drivers\sysclk; ..\..\platform\CYT4BF\hal_drivers\sysflt; ..\..\platform\CYT4BF\hal_drivers\sysreghc; ..\..\platform\CYT4BF\interrupts; ..\..\platform\CYT4BF\startup; ..\..\platform\CYT4BF\startup\include; ..\..\platform\CYT4BF\startup\src; ..\..\platform\CYT4BF\system; ..\..\platform\CYT4BF\system\include; ..\..\platform\CYT4BF\system\src; ..\..\platform\driver; ..\..\platform\driver\include; ..\..\platform\driver\src; ..\..\platform\utility\include; ..\..\platform\utility\src; ..\..\platform\BSP\can; ..\..\platform\BSP\eeprom; ..\..\platform\BSP\ethernet; ..\..\platform\BSP\gnss; ..\..\platform\BSP\gpio; ..\..\platform\BSP\imu; ..\..\platform\BSP\rs232; ..\..\platform\BSP\sta9100; ..\..\platform\BSP\watchdog; ..\..\platform\Core\configuration; ..\..\platform\Core\ucbpacket; ..\..\platform\Core\runstatus; ..\..\platform\Core\maintain_ins; ..\..\platform\time_switch; ..\..\platform\fault_det
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ins.srec
  postbuild: ..\..\create_bin.bat  $PROJ_DIR$ $PROJ_FNAME$
  ILINK.IlinkOutputFile: ins.hex
  ILINK.IlinkConfigDefines: _CORE_cm7_1_=0; _LINK_flash_=0
  ILINK.IlinkIcfFile: ..\..\..\linker\linker_directives_tviibh.icf
  ILINK.IlinkAdditionalLibs: ..\..\ins\ins_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group .vscode
    ../../.vscode/: c_cpp_properties.json iar.json launch.json settings.json tasks.json
  group app
    ../../app/: main_cm7_1.c taskINS.c
  group app/include
    ../../app/include/: app_version.h cy_project.h taskINS.h
    ../../../mem_share/: share_memory.h
  group ins
    ../../ins/: ins_interface_API.h
  group ins/src
    ../../ins/src/: fw_ins.c
  group linker
    ../../../linker/: linker_directives_tviibh.icf
  group platform
    ../../platform/: platform_version.h
  group platform/BSP/can
    ../../platform/BSP/can/: car_data.c car_data.h
  group platform/BSP/eeprom
    ../../platform/BSP/eeprom/: eeprom.c eeprom.h eepromAPI.h
  group platform/BSP/ethernet
    ../../platform/BSP/ethernet/: eth_process.c eth_process.h
  group platform/BSP/gnss
    ../../platform/BSP/gnss/: gnss.c gnss.h ublox_decoder.c ublox_decoder.h
  group platform/BSP/imu
    ../../platform/BSP/imu/: Imu330Eth.c Imu330Eth.h imu330za.c imu330za.h
  group platform/BSP/rs232
    ../../platform/BSP/rs232/: rs232.c rs232.h
  group platform/BSP/sta9100
    ../../platform/BSP/sta9100/: sta9100_control.c sta9100_control.h sta9100_upgrade.c sta9100_upgrade.h
  group platform/BSP/time_switch
    ../../platform/time_switch/: rtkcmn.c rtkcmn.h
  group platform/BSP/watchdog
    ../../platform/BSP/watchdog/: watchdog.c watchdog.h
  group platform/Core/configuration
    ../../platform/Core/configuration/: user_config.c user_config.h
  group platform/Core/maintain_ins
    ../../platform/Core/maintain_ins/: maintain_ins.c maintain_ins.h
  group platform/Core/runstatus
    ../../platform/Core/runstatus/: run_status.c run_status.h
  group platform/Core/ucbpacket
    ../../platform/Core/ucbpacket/: ucb_packet.c ucb_packet.h ucb_packet_struct.h
  group platform/cypress_sdk/flash
    ../../platform/cypress_sdk/flash/: cy_mw_flash.c cy_mw_flash.h
  group platform/cypress_sdk/power
    ../../platform/cypress_sdk/power/: cy_power.c cy_power.h
  group platform/cypress_sdk/sw_timer
    ../../platform/cypress_sdk/sw_timer/: cy_sw_tmr.c cy_sw_tmr.h
  group platform/CYT4BF/board
    ../../platform/CYT4BF/board/: bb_bsp_tviibh8m.h cy_device_headers.h cyt4a0100s.h cyt4bf8cde.h cyt4bf8cds.h cyt4bf8cee.h cyt4bf8ces.h cyt4bf_config.h cyt4bfbche.h cyt4bfbchs.h cyt4bfbcje.h cyt4bfbcjs.h cyt4bfcche.h cyt4bfcchs.h cyt4bfccje.h cyt4bfccjs.h gpio_cyt4bf_176_teqfp.h gpio_cyt4bf_176_teqfp_opb.h gpio_cyt4bf_272_bga.h gpio_cyt4bf_320_bga.h
  group platform/CYT4BF/board/ip
    ../../platform/CYT4BF/board/ip/: cyip_backup_v3.h cyip_canfd.h cyip_cpuss.h cyip_crypto.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_flexray.h cyip_gpio_v3.h cyip_headers.h cyip_hsiom_v3.h cyip_i2s_v2.h cyip_ipc.h cyip_lin.h cyip_pass.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_scb_v2.h cyip_sdhc.h cyip_sflash_v2.h cyip_smartio_v3.h cyip_smif_v2.h cyip_srss_v3.h cyip_tcpwm_v2.h
  group platform/CYT4BF/board/mcureg
    ../../platform/CYT4BF/board/mcureg/: cyreg_backup.h cyreg_canfd.h cyreg_cpuss.h cyreg_crypto.h cyreg_dmac.h cyreg_dw.h cyreg_efuse.h cyreg_efuse_data.h cyreg_eth.h cyreg_evtgen.h cyreg_fault.h cyreg_flashc.h cyreg_flexray.h cyreg_gpio.h cyreg_hsiom.h cyreg_i2s.h cyreg_ipc.h cyreg_lin.h cyreg_pass.h cyreg_peri.h cyreg_peri_ms.h cyreg_peri_pclk.h cyreg_prot.h cyreg_scb.h cyreg_sdhc.h cyreg_sflash.h cyreg_smartio.h cyreg_smif.h cyreg_srss.h cyreg_tcpwm.h mcureg.h
  group platform/CYT4BF/cmsis/include
    ../../platform/CYT4BF/cmsis/include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_ghs.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h core_cm4.h core_cm7.h mpu_armv7.h
  group platform/CYT4BF/hal_common/adc
    ../../platform/CYT4BF/hal_common/adc/: cy_adc.c cy_adc.h
  group platform/CYT4BF/hal_common/canfd
    ../../platform/CYT4BF/hal_common/canfd/: cy_canfd.c cy_canfd.h
  group platform/CYT4BF/hal_common/crypto
    ../../platform/CYT4BF/hal_common/crypto/: cy_crypto.h cy_crypto_common.h cy_crypto_config.c cy_crypto_config.h cy_crypto_server.h
  group platform/CYT4BF/hal_common/dma
    ../../platform/CYT4BF/hal_common/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group platform/CYT4BF/hal_common/evtgen
    ../../platform/CYT4BF/hal_common/evtgen/: cy_evtgen.c cy_evtgen.h
  group platform/CYT4BF/hal_common/flash
    ../../platform/CYT4BF/hal_common/flash/: cy_flash.c cy_flash.h
  group platform/CYT4BF/hal_common/gpio
    ../../platform/CYT4BF/hal_common/gpio/: cy_gpio.c cy_gpio.h
  group platform/CYT4BF/hal_common/ipc
    ../../platform/CYT4BF/hal_common/ipc/: cy_ipc_config.h cy_ipc_drv.c cy_ipc_drv.h cy_ipc_pipe.c cy_ipc_pipe.h cy_ipc_sema.c cy_ipc_sema.h
  group platform/CYT4BF/hal_common/lin
    ../../platform/CYT4BF/hal_common/lin/: cy_lin.c cy_lin.h
  group platform/CYT4BF/hal_common/lvd
    ../../platform/CYT4BF/hal_common/lvd/: cy_lvd.c cy_lvd.h
  group platform/CYT4BF/hal_common/mcwdt
    ../../platform/CYT4BF/hal_common/mcwdt/: cy_mcwdt.c cy_mcwdt.h
  group platform/CYT4BF/hal_common/mpu
    ../../platform/CYT4BF/hal_common/mpu/: cy_mpu.c cy_mpu.h
  group platform/CYT4BF/hal_common/prot
    ../../platform/CYT4BF/hal_common/prot/: cy_prot.c cy_prot.h
  group platform/CYT4BF/hal_common/scb
    ../../platform/CYT4BF/hal_common/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group platform/CYT4BF/hal_common/smartio
    ../../platform/CYT4BF/hal_common/smartio/: cy_smartio.c cy_smartio.h
  group platform/CYT4BF/hal_common/srom
    ../../platform/CYT4BF/hal_common/srom/: cy_srom.c cy_srom.h
  group platform/CYT4BF/hal_common/sysflt
    ../../platform/CYT4BF/hal_common/sysflt/: cy_sysflt.c cy_sysflt.h
  group platform/CYT4BF/hal_common/sysint
    ../../platform/CYT4BF/hal_common/sysint/: cy_sysint.c cy_sysint.h
  group platform/CYT4BF/hal_common/syslib
    ../../platform/CYT4BF/hal_common/syslib/: cy_syslib.c cy_syslib.h
  group platform/CYT4BF/hal_common/syslib/ghs
    ../../platform/CYT4BF/hal_common/syslib/ghs/: cy_syslib_ghs.arm
  group platform/CYT4BF/hal_common/syslib/iar
    ../../platform/CYT4BF/hal_common/syslib/iar/: cy_syslib_iar.s
  group platform/CYT4BF/hal_common/syspm
    ../../platform/CYT4BF/hal_common/syspm/: cy_syspm.c cy_syspm.h
  group platform/CYT4BF/hal_common/sysreset
    ../../platform/CYT4BF/hal_common/sysreset/: cy_sysreset.c cy_sysreset.h
  group platform/CYT4BF/hal_common/sysrtc
    ../../platform/CYT4BF/hal_common/sysrtc/: cy_sysrtc.c cy_sysrtc.h
  group platform/CYT4BF/hal_common/systick
    ../../platform/CYT4BF/hal_common/systick/: cy_systick.c cy_systick.h
  group platform/CYT4BF/hal_common/syswdt
    ../../platform/CYT4BF/hal_common/syswdt/: cy_syswdt.c cy_syswdt.h
  group platform/CYT4BF/hal_common/tcpwm
    ../../platform/CYT4BF/hal_common/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group platform/CYT4BF/hal_common/trigmux
    ../../platform/CYT4BF/hal_common/trigmux/: cy_trigmux.c cy_trigmux.h
  group platform/CYT4BF/hal_drivers/audioss
    ../../platform/CYT4BF/hal_drivers/audioss/: cy_i2s.c cy_i2s.h
  group platform/CYT4BF/hal_drivers/canfd
    ../../platform/CYT4BF/hal_drivers/canfd/: cy_canfd_config.h
  group platform/CYT4BF/hal_drivers/cpu
    ../../platform/CYT4BF/hal_drivers/cpu/: cy_cpu.c cy_cpu.h
  group platform/CYT4BF/hal_drivers/crypto/libs
    ../../platform/CYT4BF/hal_drivers/crypto/libs/: libcrypto_client_cm7_0_iar.a libcrypto_client_cm7_1_iar.a libcrypto_server_cm0plus_iar.a
  group platform/CYT4BF/hal_drivers/ethernet
    ../../platform/CYT4BF/hal_drivers/ethernet/: cdn_errno.h cdn_stdint.h cedi.h cps_v2.h cy_ethif.c cy_ethif.h cy_ethif_defines.h edd.c edd_int.h edd_rx.c edd_tx.c emac_regs.h emac_regs_macro.h log.h
  group platform/CYT4BF/hal_drivers/flexray
    ../../platform/CYT4BF/hal_drivers/flexray/: cy_fr.h
  group platform/CYT4BF/hal_drivers/flexray/api
    ../../platform/CYT4BF/hal_drivers/flexray/api/: cy_fr_api_control_service.c cy_fr_api_control_service.h cy_fr_api_global.h cy_fr_api_init.c cy_fr_api_init.h cy_fr_api_interrupt_service.c cy_fr_api_interrupt_service.h cy_fr_api_rx_handler.c cy_fr_api_rx_handler.h cy_fr_api_status_service.c cy_fr_api_status_service.h cy_fr_api_time_service.c cy_fr_api_time_service.h cy_fr_api_timer_service.c cy_fr_api_timer_service.h cy_fr_api_tx_handler.c cy_fr_api_tx_handler.h
  group platform/CYT4BF/hal_drivers/flexray/ccal
    ../../platform/CYT4BF/hal_drivers/flexray/ccal/: cy_fr_ccal_control_service.c cy_fr_ccal_control_service.h cy_fr_ccal_init.c cy_fr_ccal_init.h cy_fr_ccal_interrupt_service.c cy_fr_ccal_interrupt_service.h cy_fr_ccal_rx_handler.c cy_fr_ccal_rx_handler.h cy_fr_ccal_status_service.c cy_fr_ccal_status_service.h cy_fr_ccal_time_service.c cy_fr_ccal_time_service.h cy_fr_ccal_timer_service.c cy_fr_ccal_timer_service.h cy_fr_ccal_tx_handler.c cy_fr_ccal_tx_handler.h
  group platform/CYT4BF/hal_drivers/flexray/fhal
    ../../platform/CYT4BF/hal_drivers/flexray/fhal/: cy_fr_fhal.h cy_fr_fhal_register.h
  group platform/CYT4BF/hal_drivers/sd_host
    ../../platform/CYT4BF/hal_drivers/sd_host/: cy_sd_host.c cy_sd_host.h
  group platform/CYT4BF/hal_drivers/smif
    ../../platform/CYT4BF/hal_drivers/smif/: cy_smif.c cy_smif.h cy_smif_memslot.c cy_smif_memslot.h
  group platform/CYT4BF/hal_drivers/sysclk
    ../../platform/CYT4BF/hal_drivers/sysclk/: cy_sysclk.c cy_sysclk.h
  group platform/CYT4BF/hal_drivers/sysflt
    ../../platform/CYT4BF/hal_drivers/sysflt/: cy_sysflt_config.h
  group platform/CYT4BF/hal_drivers/sysreghc
    ../../platform/CYT4BF/hal_drivers/sysreghc/: cy_sysreghc.c cy_sysreghc.h
  group platform/CYT4BF/interrupts
    ../../platform/CYT4BF/interrupts/: cy_interrupt_map.c cy_interrupt_map_cm0plus.h cy_interrupt_map_cm7_0.h cy_interrupt_map_cm7_1.h
  group platform/CYT4BF/startup/include
    ../../platform/CYT4BF/startup/include/: startup_customize.h
  group platform/CYT4BF/startup/src
    ../../platform/CYT4BF/startup/src/: startup.c startup_cm7.s
  group platform/CYT4BF/system/include
    ../../platform/CYT4BF/system/include/: system_cyt4bf.h
  group platform/CYT4BF/system/src
    ../../platform/CYT4BF/system/src/: system_tviibh8m_cm7.c
  group platform/driver/include
    ../../platform/driver/include/: can.h ethernet.h mcu_temperature.h timer.h uart.h
  group platform/driver/src
    ../../platform/driver/src/: can.c ethernet.c m7_ipc.c mcu_temperature.c timer.c uart.c
  group platform/fault_det
    ../../platform/fault_det/: fd_adc.c fd_clock.c fd_flash.c fd_power.c fd_public.h fd_ram.c fd_wdg.c
  group platform/utility/include
    ../../platform/utility/include/: constants.h crc.h crc16.h nav_math.h typedefs.h utils.h
  group platform/utility/src
    ../../platform/utility/src/: crc.c crc16.c nav_math.c utils.c
