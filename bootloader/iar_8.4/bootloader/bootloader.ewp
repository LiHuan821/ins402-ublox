# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT4BF_M0+ Cypress CYT4BF_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: tviibh8m; CYT4BFBCHS; CY_USE_PSVP=0; CY_MCU_rev_b; CPU_BOARD_REVA
  ICCARM.CCIncludePath2: ..\..\app; ..\..\app\include; ..\..\linker; ..\..\platform; ..\..\platform\cypress_sdk; ..\..\platform\cypress_sdk\flash; ..\..\platform\cypress_sdk\power; ..\..\platform\cypress_sdk\sw_timer; ..\..\platform\CYT4BF; ..\..\platform\CYT4BF\board; ..\..\platform\CYT4BF\board\ip; ..\..\platform\CYT4BF\board\mcureg; ..\..\platform\CYT4BF\cmsis; ..\..\platform\CYT4BF\cmsis\include; ..\..\platform\CYT4BF\hal_common; ..\..\platform\CYT4BF\hal_drivers; ..\..\platform\CYT4BF\interrupts; ..\..\platform\CYT4BF\startup; ..\..\platform\CYT4BF\startup\include; ..\..\platform\CYT4BF\startup\src; ..\..\platform\CYT4BF\system; ..\..\platform\CYT4BF\system\include; ..\..\platform\CYT4BF\system\src; ..\..\platform\driver; ..\..\platform\driver\include; ..\..\platform\driver\src; ..\..\platform\UARTComm; ..\..\platform\utility; ..\..\platform\utility\include; ..\..\platform\utility\src; ..\..\platform\eeprom; ..\..\platform\eeprom\include; ..\..\platform\tool\include; ..\..\platform\sta9100; ..\..\platform\ethernet; ..\..\app\user
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.srec
  postbuild: ..\..\create_bin.bat  $PROJ_DIR$ $PROJ_FNAME$
  ILINK.IlinkOutputFile: bootloader.hex
  ILINK.IlinkConfigDefines: _CORE_$PROJ_FNAME$_=0; _LINK_flash_=0
  ILINK.IlinkIcfFile: ..\..\..\linker\linker_directives_tviibh.icf
  ILINK.IlinkAdditionalLibs: ..\..\platform\CYT4BF\hal_drivers\crypto\libs\libcrypto_server_cm0plus_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../app/: main_cm0.c
  group app/include
    ../../app/include/: app_version.h bsp.h cy_project.h
    ../../app/user/: status_handler.h
  group app/user
    ../../app/user/: bsp.c status_handler.c
  group linker
    ../../../linker/: linker_directives_tviibh.icf
  group platform
    ../../platform/: platform_version.h platformAPI.h
  group platform/cypress_sdk/flash
    ../../platform/cypress_sdk/flash/: cy_mw_flash.c cy_mw_flash.h
  group platform/cypress_sdk/power
    ../../platform/cypress_sdk/power/: cy_power.c cy_power.h
  group platform/cypress_sdk/sw_timer
    ../../platform/cypress_sdk/sw_timer/: cy_sw_tmr.c cy_sw_tmr.h
  group platform/CYT4BF/board
    ../../platform/CYT4BF/board/: bb_bsp_tviibh8m.h cy_device_headers.h cyt4a0100s.h cyt4bf8cde.h cyt4bf8cds.h cyt4bf8cee.h cyt4bf8ces.h cyt4bf_config.h cyt4bfbche.h cyt4bfbchs.h cyt4bfbcje.h cyt4bfbcjs.h cyt4bfcche.h cyt4bfcchs.h cyt4bfccje.h cyt4bfccjs.h gpio_cyt4bf_176_teqfp.h gpio_cyt4bf_176_teqfp_opb.h gpio_cyt4bf_272_bga.h gpio_cyt4bf_320_bga.h
  group platform/CYT4BF/board/ip
    ../../platform/CYT4BF/board/ip/: cyip_backup_v3.h cyip_canfd.h cyip_cpuss.h cyip_crypto.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_flexray.h cyip_gpio_v3.h cyip_headers.h cyip_hsiom_v3.h cyip_i2s_v2.h cyip_ipc.h cyip_lin.h cyip_pass.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_scb_v2.h cyip_sdhc.h cyip_sflash_v2.h cyip_smartio_v3.h cyip_smif_v2.h cyip_srss_v3.h cyip_tcpwm_v2.h
  group platform/CYT4BF/board/mcureg
    ../../platform/CYT4BF/board/mcureg/: cyreg_backup.h cyreg_canfd.h cyreg_cpuss.h cyreg_crypto.h cyreg_dmac.h cyreg_dw.h cyreg_efuse.h cyreg_efuse_data.h cyreg_eth.h cyreg_evtgen.h cyreg_fault.h cyreg_flashc.h cyreg_flexray.h cyreg_gpio.h cyreg_hsiom.h cyreg_i2s.h cyreg_ipc.h cyreg_lin.h cyreg_pass.h cyreg_peri.h cyreg_peri_ms.h cyreg_peri_pclk.h cyreg_prot.h cyreg_scb.h cyreg_sdhc.h cyreg_sflash.h cyreg_smartio.h cyreg_smif.h cyreg_srss.h cyreg_tcpwm.h mcureg.h
  group platform/CYT4BF/cmsis/include
    ../../platform/CYT4BF/cmsis/include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_ghs.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h core_cm4.h core_cm7.h mpu_armv7.h
  group platform/CYT4BF/hal/adc
    ../../platform/CYT4BF/hal_common/adc/: cy_adc.c cy_adc.h
  group platform/CYT4BF/hal/audioss
    ../../platform/CYT4BF/hal_drivers/audioss/: cy_i2s.c cy_i2s.h
  group platform/CYT4BF/hal/canfd
    ../../platform/CYT4BF/hal_common/canfd/: cy_canfd.c cy_canfd.h
    ../../platform/CYT4BF/hal_drivers/canfd/: cy_canfd_config.h
  group platform/CYT4BF/hal/cpu
    ../../platform/CYT4BF/hal_drivers/cpu/: cy_cpu.c cy_cpu.h
  group platform/CYT4BF/hal/crypto
    ../../platform/CYT4BF/hal_common/crypto/: cy_crypto.h cy_crypto_common.h cy_crypto_config.c cy_crypto_config.h cy_crypto_server.h
  group platform/CYT4BF/hal/crypto/libs
    ../../platform/CYT4BF/hal_drivers/crypto/libs/: libcrypto_client_cm7_0_iar.a libcrypto_client_cm7_1_iar.a libcrypto_server_cm0plus_iar.a
  group platform/CYT4BF/hal/dma
    ../../platform/CYT4BF/hal_common/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group platform/CYT4BF/hal/ethernet
    ../../platform/CYT4BF/hal_drivers/ethernet/: cdn_errno.h cdn_stdint.h cedi.h cps_v2.h cy_ethif.c cy_ethif.h cy_ethif_defines.h edd.c edd_int.h edd_rx.c edd_tx.c emac_regs.h emac_regs_macro.h log.h
  group platform/CYT4BF/hal/evtgen
    ../../platform/CYT4BF/hal_common/evtgen/: cy_evtgen.c cy_evtgen.h
  group platform/CYT4BF/hal/flash
    ../../platform/CYT4BF/hal_common/flash/: cy_flash.c cy_flash.h
  group platform/CYT4BF/hal/flexray/api
    ../../platform/CYT4BF/hal_drivers/flexray/api/: cy_fr_api_control_service.c cy_fr_api_control_service.h cy_fr_api_global.h cy_fr_api_init.c cy_fr_api_init.h cy_fr_api_interrupt_service.c cy_fr_api_interrupt_service.h cy_fr_api_rx_handler.c cy_fr_api_rx_handler.h cy_fr_api_status_service.c cy_fr_api_status_service.h cy_fr_api_time_service.c cy_fr_api_time_service.h cy_fr_api_timer_service.c cy_fr_api_timer_service.h cy_fr_api_tx_handler.c cy_fr_api_tx_handler.h
  group platform/CYT4BF/hal/flexray/ccal
    ../../platform/CYT4BF/hal_drivers/flexray/ccal/: cy_fr_ccal_control_service.c cy_fr_ccal_control_service.h cy_fr_ccal_init.c cy_fr_ccal_init.h cy_fr_ccal_interrupt_service.c cy_fr_ccal_interrupt_service.h cy_fr_ccal_rx_handler.c cy_fr_ccal_rx_handler.h cy_fr_ccal_status_service.c cy_fr_ccal_status_service.h cy_fr_ccal_time_service.c cy_fr_ccal_time_service.h cy_fr_ccal_timer_service.c cy_fr_ccal_timer_service.h cy_fr_ccal_tx_handler.c cy_fr_ccal_tx_handler.h
  group platform/CYT4BF/hal/gpio
    ../../platform/CYT4BF/hal_common/gpio/: cy_gpio.c cy_gpio.h
  group platform/CYT4BF/hal/ipc
    ../../platform/CYT4BF/hal_common/ipc/: cy_ipc_config.h cy_ipc_drv.c cy_ipc_drv.h cy_ipc_pipe.c cy_ipc_pipe.h cy_ipc_sema.c cy_ipc_sema.h
  group platform/CYT4BF/hal/lin
    ../../platform/CYT4BF/hal_common/lin/: cy_lin.c cy_lin.h
  group platform/CYT4BF/hal/lvd
    ../../platform/CYT4BF/hal_common/lvd/: cy_lvd.c cy_lvd.h
  group platform/CYT4BF/hal/mcwdt
    ../../platform/CYT4BF/hal_common/mcwdt/: cy_mcwdt.c cy_mcwdt.h
  group platform/CYT4BF/hal/mpu
    ../../platform/CYT4BF/hal_common/mpu/: cy_mpu.c cy_mpu.h
  group platform/CYT4BF/hal/prot
    ../../platform/CYT4BF/hal_common/prot/: cy_prot.c cy_prot.h
  group platform/CYT4BF/hal/scb
    ../../platform/CYT4BF/hal_common/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group platform/CYT4BF/hal/sd_host
    ../../platform/CYT4BF/hal_drivers/sd_host/: cy_sd_host.c cy_sd_host.h
  group platform/CYT4BF/hal/smartio
    ../../platform/CYT4BF/hal_common/smartio/: cy_smartio.c cy_smartio.h
  group platform/CYT4BF/hal/smif
    ../../platform/CYT4BF/hal_drivers/smif/: cy_smif.c cy_smif.h cy_smif_memslot.c cy_smif_memslot.h
  group platform/CYT4BF/hal/srom
    ../../platform/CYT4BF/hal_common/srom/: cy_srom.c cy_srom.h
  group platform/CYT4BF/hal/sysclk
    ../../platform/CYT4BF/hal_drivers/sysclk/: cy_sysclk.c cy_sysclk.h
  group platform/CYT4BF/hal/sysflt
    ../../platform/CYT4BF/hal_common/sysflt/: cy_sysflt.c cy_sysflt.h
    ../../platform/CYT4BF/hal_drivers/sysflt/: cy_sysflt_config.h
  group platform/CYT4BF/hal/sysint
    ../../platform/CYT4BF/hal_common/sysint/: cy_sysint.c cy_sysint.h
  group platform/CYT4BF/hal/syslib
    ../../platform/CYT4BF/hal_common/syslib/: cy_syslib.c cy_syslib.h
    ../../platform/CYT4BF/hal_common/syslib/iar/: cy_syslib_iar.s
  group platform/CYT4BF/hal/syspm
    ../../platform/CYT4BF/hal_common/syspm/: cy_syspm.c cy_syspm.h
  group platform/CYT4BF/hal/sysreghc
    ../../platform/CYT4BF/hal_drivers/sysreghc/: cy_sysreghc.c cy_sysreghc.h
  group platform/CYT4BF/hal/sysreset
    ../../platform/CYT4BF/hal_common/sysreset/: cy_sysreset.c cy_sysreset.h
  group platform/CYT4BF/hal/sysrtc
    ../../platform/CYT4BF/hal_common/sysrtc/: cy_sysrtc.c cy_sysrtc.h
  group platform/CYT4BF/hal/systick
    ../../platform/CYT4BF/hal_common/systick/: cy_systick.c cy_systick.h
  group platform/CYT4BF/hal/syswdt
    ../../platform/CYT4BF/hal_common/syswdt/: cy_syswdt.c cy_syswdt.h
  group platform/CYT4BF/hal/tcpwm
    ../../platform/CYT4BF/hal_common/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group platform/CYT4BF/hal/trigmux
    ../../platform/CYT4BF/hal_common/trigmux/: cy_trigmux.c cy_trigmux.h
  group platform/CYT4BF/interrupts
    ../../platform/CYT4BF/interrupts/: cy_interrupt_map.c cy_interrupt_map_cm0plus.h cy_interrupt_map_cm7_0.h cy_interrupt_map_cm7_1.h
  group platform/CYT4BF/startup/include
    ../../platform/CYT4BF/startup/include/: startup_customize.h
  group platform/CYT4BF/startup/src
    ../../platform/CYT4BF/startup/src/: startup.c startup_cm0plus.s
  group platform/CYT4BF/system/include
    ../../platform/CYT4BF/system/include/: system_cyt4bf.h
  group platform/CYT4BF/system/src
    ../../platform/CYT4BF/system/src/: system_tviibh8m_cm0plus.c
  group platform/driver/include
    ../../platform/driver/include/: ethernet.h led.h uart.h
  group platform/driver/src
    ../../platform/driver/src/: ethernet.c led.c uart.c
  group platform/eeprom
    ../../platform/eeprom/: eepromAPI.h
  group platform/eeprom/include
    ../../platform/eeprom/include/: eeprom.h
  group platform/eeprom/src
    ../../platform/eeprom/src/: eeprom.c
  group platform/ethernet
    ../../platform/ethernet/: eth_process.c eth_process.h
  group platform/systime
    ../../platform/systime/: synctime.c synctime.h systime.c systime.h
  group platform/tool/include
    ../../platform/tool/include/: ucb_packet.h
  group platform/tool/src
    ../../platform/tool/src/: handle_packet.c platform.c send_packet.c
  group platform/utility/include
    ../../platform/utility/include/: crc16.h fifo.h
  group platform/utility/src
    ../../platform/utility/src/: crc16.c fifo.c
